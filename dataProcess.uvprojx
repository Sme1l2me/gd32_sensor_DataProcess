# Keil uVision project dataProcess.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F103RG GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: dataProcess +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_XD
  c include: .\Firmware\CMSIS;.\user;.\Firmware\CMSIS\GD\GD32F10x\Include;.\Firmware\GD32F10x_standard_peripheral\Include;.\sensor\aht20;.\sensor\common;.\sensor\gm702b;.\sensor\jxo2101;.\sensor\lxdgb5a1dphy;.\sensor\m2313;.\sensor\mhz19d;.\sensor\msm261s4030h0r;.\sensor\pms9103s;.\sensor\qmi8658a;.\sensor\crd1503g;.\sensor\cx1088;.\sensor\electro_radiation_sensor;.\sensor\bmp390
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group user
    ./user/: gd32f10x_it.c main.c systick.c
  group Firmware
    ./Firmware/GD32F10x_standard_peripheral/Source/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
  group CMSIS
    ./Firmware/CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
  group sensor
    ./sensor/aht20/: aht20.c
    ./sensor/common/: common.c
    ./sensor/gm702b/: gm702b.c
    ./sensor/jxo2101/: jxo2101.c
    ./sensor/lxdgb5a1dphy/: lxdgb5a1dphy.c
    ./sensor/m2313/: m2313.c
    ./sensor/mhz19d/: mhz19d.c
    ./sensor/msm261s4030h0r/: msm261s4030h0r.c
    ./sensor/pms9103s/: pms9103s.c
    ./sensor/qmi8658a/: qmi8658a.c
    ./sensor/crd1503g/: crd1503g.c
    ./sensor/cx1088/: cx1088.c
    ./sensor/electro_radiation_sensor/: e_r_sensor.c
    ./sensor/bmp390/: bmp390.c
  group Startup
    ./Startup/: startup_gd32f10x_xd.s
